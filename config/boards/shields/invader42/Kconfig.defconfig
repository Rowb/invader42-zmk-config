## config/boards/shields/invader42/Kconfig.defconfig
```kconfig
if INVADER42

config ZMK_KEYBOARD_NAME
    default "invader42"

    CONFIG_ZMK_BATTERY_REPORTING=Y
    
endif
```
